<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\modelo_C_asm_1343.ewp</path>
  </project>
  <batchBuild/>
</workspace>


